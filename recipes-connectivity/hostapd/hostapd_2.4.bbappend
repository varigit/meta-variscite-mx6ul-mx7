do_install_append_mx6ul() {
    chmod -x ${D}${sysconfdir}/init.d/hostapd
}
